# Keil uVision project sample.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: smartguard_control +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F030,USE_STDPERIPH_DRIVER,TQ_DEBUG
  c misc: --asm
  c include: .;..\..\tinyq\hw\stm32f030\stm_driver\STM32F0xx_StdPeriph_Driver\inc;..\..\tinyq\hw\stm32f030\stm_driver\CMSIS\Device\ST\STM32F0xx\Include;..\..\tinyq\hw\stm32f030;..\..\tinyq\core;..\..\tinyq\misc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group sample
    ./: stm32f0xx_conf.h main.c
  group tinyq
    ../../tinyq/core/: qti_system.c qti_system.h tinyq.c tinyq.h tq_types.h
  group qties
    ./qties/: qties.c qti_indication.c qti_button.c qti_sample.c
  group tq_misc
    ../../tinyq/misc/: ring_buffer.c state_machine.c interpolator.c
  group tq_hw
    ../../tinyq/hw/stm32f030/: hw_debug.c hw_debug.h hw_exti.c hw_exti.h hw_gpio.h tq_port.c tq_port.h
  group stm_driver
    ../../tinyq/hw/stm32f030/stm_driver/STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_gpio.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_usart.h
    ../../tinyq/hw/stm32f030/stm_driver/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_flash.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.5.0
